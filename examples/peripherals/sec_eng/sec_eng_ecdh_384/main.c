#include "bflb_mtimer.h"
#include "bflb_sec_ecdsa.h"
#include "board.h"

#define ALGORITHM_TYPE 0

/* We use following two case to show how ECDH works*/
//==========================
//Alice's secret key:   e7baff6d2b6a79874b64df185e7a0962f1c48a59506d2e8309a9c0126a6f24a9d8899bc8ae4573ad5b796092fa69c86a
//Alice's public key:   (98a140149fe5b106fc840915033363091aa2630e11052c764bd8bf792d166873d1524fdaf6098e7b26aa2e69a975a3b8, 5c2b03e4b8822c61924c11077c31b154beaabfdb7ad23ddb872ec9a7c5e5775fc2f59bae49d2365afca97bb97f49b725)
//Bob's secret key:   fd43e4d2c871d1eca0e14607718541ebe1f5da9ffc7c5c2b1f31c69c01ac95d10d81a8ad04aa851f27e85d1da58bb293
//Bob's public key: (92e0ca23401264b9520c82c208c5c26311d6ee68b2dfe97389973e4d4883bb982fccb5ceaf69afbe70fbe4c527b88de8, 83d2961d272b481e917f7db3e0be93440253407b9efc60cc93da5ef4e6e2859453ecb215911874824400d1c5345bcab4)
//==========================
//Alice's shared key:   (40c405bd89ad9bdbda109f36ef415afee03eac0b3c346561969b5cd328e1023125069bb0c9d8f4c37ef796880aff7cb3)
//Bob's shared key: (40c405bd89ad9bdbda109f36ef415afee03eac0b3c346561969b5cd328e1023125069bb0c9d8f4c37ef796880aff7cb3)
//==========================
//The shared value is the x-value:  40c405bd89ad9bdbda109f36ef415afee03eac0b3c346561969b5cd328e1023125069bb0c9d8f4c37ef796880aff7cb3
uint8_t secp384r1_ecdh_private_key1[48] = { 0xe7, 0xba, 0xff, 0x6d, 0x2b, 0x6a, 0x79, 0x87, 0x4b, 0x64, 0xdf, 0x18, 0x5e, 0x7a, 0x09, 0x62,
                                            0xf1, 0xc4, 0x8a, 0x59, 0x50, 0x6d, 0x2e, 0x83, 0x09, 0xa9, 0xc0, 0x12, 0x6a, 0x6f, 0x24, 0xa9,
                                            0xd8, 0x89, 0x9b, 0xc8, 0xae, 0x45, 0x73, 0xad, 0x5b, 0x79, 0x60, 0x92, 0xfa, 0x69, 0xc8, 0x6a };
uint8_t secp384r1_ecdh_public_keyx1[48] = { 0x98, 0xa1, 0x40, 0x14, 0x9f, 0xe5, 0xb1, 0x06, 0xfc, 0x84, 0x09, 0x15, 0x03, 0x33, 0x63, 0x09,
                                            0x1a, 0xa2, 0x63, 0x0e, 0x11, 0x05, 0x2c, 0x76, 0x4b, 0xd8, 0xbf, 0x79, 0x2d, 0x16, 0x68, 0x73,
                                            0xd1, 0x52, 0x4f, 0xda, 0xf6, 0x09, 0x8e, 0x7b, 0x26, 0xaa, 0x2e, 0x69, 0xa9, 0x75, 0xa3, 0xb8 };
uint8_t secp384r1_ecdh_public_keyy1[48] = { 0x5c, 0x2b, 0x03, 0xe4, 0xb8, 0x82, 0x2c, 0x61, 0x92, 0x4c, 0x11, 0x07, 0x7c, 0x31, 0xb1, 0x54,
                                            0xbe, 0xaa, 0xbf, 0xdb, 0x7a, 0xd2, 0x3d, 0xdb, 0x87, 0x2e, 0xc9, 0xa7, 0xc5, 0xe5, 0x77, 0x5f,
                                            0xc2, 0xf5, 0x9b, 0xae, 0x49, 0xd2, 0x36, 0x5a, 0xfc, 0xa9, 0x7b, 0xb9, 0x7f, 0x49, 0xb7, 0x25 };
uint8_t secp384r1_ecdh_shared_keyx1[48] = { 0x40, 0xc4, 0x05, 0xbd, 0x89, 0xad, 0x9b, 0xdb, 0xda, 0x10, 0x9f, 0x36, 0xef, 0x41, 0x5a, 0xfe,
                                            0xe0, 0x3e, 0xac, 0x0b, 0x3c, 0x34, 0x65, 0x61, 0x96, 0x9b, 0x5c, 0xd3, 0x28, 0xe1, 0x02, 0x31,
                                            0x25, 0x06, 0x9b, 0xb0, 0xc9, 0xd8, 0xf4, 0xc3, 0x7e, 0xf7, 0x96, 0x88, 0x0a, 0xff, 0x7c, 0xb3 };

uint8_t secp384r1_ecdh_private_key2[48] = { 0xfd, 0x43, 0xe4, 0xd2, 0xc8, 0x71, 0xd1, 0xec, 0xa0, 0xe1, 0x46, 0x07, 0x71, 0x85, 0x41, 0xeb,
                                            0xe1, 0xf5, 0xda, 0x9f, 0xfc, 0x7c, 0x5c, 0x2b, 0x1f, 0x31, 0xc6, 0x9c, 0x01, 0xac, 0x95, 0xd1,
                                            0x0d, 0x81, 0xa8, 0xad, 0x04, 0xaa, 0x85, 0x1f, 0x27, 0xe8, 0x5d, 0x1d, 0xa5, 0x8b, 0xb2, 0x93 };
uint8_t secp384r1_ecdh_public_keyx2[48] = { 0x92, 0xe0, 0xca, 0x23, 0x40, 0x12, 0x64, 0xb9, 0x52, 0x0c, 0x82, 0xc2, 0x08, 0xc5, 0xc2, 0x63,
                                            0x11, 0xd6, 0xee, 0x68, 0xb2, 0xdf, 0xe9, 0x73, 0x89, 0x97, 0x3e, 0x4d, 0x48, 0x83, 0xbb, 0x98,
                                            0x2f, 0xcc, 0xb5, 0xce, 0xaf, 0x69, 0xaf, 0xbe, 0x70, 0xfb, 0xe4, 0xc5, 0x27, 0xb8, 0x8d, 0xe8 };
uint8_t secp384r1_ecdh_public_keyy2[48] = { 0x83, 0xd2, 0x96, 0x1d, 0x27, 0x2b, 0x48, 0x1e, 0x91, 0x7f, 0x7d, 0xb3, 0xe0, 0xbe, 0x93, 0x44,
                                            0x02, 0x53, 0x40, 0x7b, 0x9e, 0xfc, 0x60, 0xcc, 0x93, 0xda, 0x5e, 0xf4, 0xe6, 0xe2, 0x85, 0x94,
                                            0x53, 0xec, 0xb2, 0x15, 0x91, 0x18, 0x74, 0x82, 0x44, 0x00, 0xd1, 0xc5, 0x34, 0x5b, 0xca, 0xb4 };
uint8_t secp384r1_ecdh_shared_keyx2[48] = { 0x40, 0xc4, 0x05, 0xbd, 0x89, 0xad, 0x9b, 0xdb, 0xda, 0x10, 0x9f, 0x36, 0xef, 0x41, 0x5a, 0xfe,
                                            0xe0, 0x3e, 0xac, 0x0b, 0x3c, 0x34, 0x65, 0x61, 0x96, 0x9b, 0x5c, 0xd3, 0x28, 0xe1, 0x02, 0x31,
                                            0x25, 0x06, 0x9b, 0xb0, 0xc9, 0xd8, 0xf4, 0xc3, 0x7e, 0xf7, 0x96, 0x88, 0x0a, 0xff, 0x7c, 0xb3 };
uint8_t secp384r1_ecdh_private_key[48] = { 0xd7, 0x3e, 0x3e, 0xb5, 0x6d, 0x7e, 0x93, 0xf4, 0x6e, 0x62, 0x57, 0x1a, 0x47, 0x2a, 0xdc, 0x58,
                                           0x92, 0x4b, 0x66, 0x23, 0xed, 0x4f, 0x0b, 0x4e, 0xb1, 0xa8, 0xcf, 0xbf, 0x98, 0x5e, 0x00, 0x8f,
                                           0xc9, 0xe8, 0xd8, 0x3d, 0xd7, 0x4e, 0x3c, 0x24, 0x71, 0xbe, 0x01, 0x22, 0xab, 0xb9, 0xc0, 0x4b };
uint8_t secp384r1_ecdh_public_keyx[48] = { 0xf7, 0xa8, 0x3a, 0x35, 0xf2, 0x96, 0xc6, 0x15, 0xa6, 0x67, 0xc4, 0x60, 0x07, 0x70, 0x40, 0x1f,
                                           0x83, 0x01, 0xeb, 0xf2, 0x3d, 0xb7, 0x5f, 0x95, 0x06, 0x05, 0x8b, 0xa1, 0x26, 0x2b, 0x00, 0x37,
                                           0x95, 0x84, 0xf5, 0x73, 0xa9, 0xe2, 0x43, 0x51, 0xdd, 0xd8, 0xeb, 0xb0, 0xaf, 0x32, 0x87, 0x15 };
uint8_t secp384r1_ecdh_public_keyy[48] = { 0xd6, 0x27, 0x24, 0x51, 0xc9, 0x2a, 0xaf, 0x18, 0xa0, 0xa3, 0x20, 0xf3, 0x69, 0x7d, 0x06, 0xe3,
                                           0x29, 0xbb, 0x2b, 0x50, 0x95, 0x7b, 0xd5, 0xcf, 0x51, 0x9d, 0x35, 0xfa, 0x06, 0xc0, 0xd9, 0xe2,
                                           0x88, 0x85, 0xa5, 0xd0, 0xc1, 0x74, 0x4d, 0xa1, 0x8b, 0x50, 0x80, 0x24, 0xa6, 0x05, 0xf3, 0xd8 };
uint8_t secp384r1_ecdh_shared_keyx[48] = { 0xd3, 0x6f, 0x35, 0x44, 0xbd, 0x54, 0xd1, 0xd7, 0x69, 0xf8, 0x32, 0xe3, 0xda, 0x5c, 0x53, 0x68,
                                           0x7a, 0xd4, 0x96, 0x30, 0xd8, 0xc0, 0x43, 0x6d, 0x3a, 0xdd, 0xed, 0x16, 0x76, 0x3a, 0x8e, 0x80,
                                           0x31, 0xad, 0xfd, 0x31, 0xbd, 0xe0, 0xeb, 0x75, 0xda, 0x2f, 0xd8, 0x9b, 0xe9, 0xa6, 0xb6, 0x87};

#define BUFF_COPY(G)                                          \
    {                                                         \
        memcpy(ecdh_private_key1, G##_ecdh_private_key1, 48); \
        memcpy(ecdh_public_keyx1, G##_ecdh_public_keyx1, 48); \
        memcpy(ecdh_public_keyy1, G##_ecdh_public_keyy1, 48); \
        memcpy(ecdh_shared_keyx1, G##_ecdh_shared_keyx1, 48); \
        memcpy(ecdh_private_key2, G##_ecdh_private_key2, 48); \
        memcpy(ecdh_public_keyx2, G##_ecdh_public_keyx2, 48); \
        memcpy(ecdh_public_keyy2, G##_ecdh_public_keyy2, 48); \
        memcpy(ecdh_shared_keyx2, G##_ecdh_shared_keyx2, 48); \
        memcpy(ecdh_private_key, G##_ecdh_private_key, 48);   \
        memcpy(ecdh_public_keyx, G##_ecdh_public_keyx, 48);   \
        memcpy(ecdh_public_keyy, G##_ecdh_public_keyy, 48);   \
        memcpy(ecdh_shared_keyx, G##_ecdh_shared_keyx, 48);   \
    }

int main(void)
{
    uint8_t ecdh_private_key1[48];
    uint8_t ecdh_public_keyx1[48];
    uint8_t ecdh_public_keyy1[48];
    uint8_t ecdh_shared_keyx1[48];

    uint8_t ecdh_private_key2[48];
    uint8_t ecdh_public_keyx2[48];
    uint8_t ecdh_public_keyy2[48];
    uint8_t ecdh_shared_keyx2[48];

    uint8_t ecdh_private_key[48];
    uint8_t ecdh_public_keyx[48];
    uint8_t ecdh_public_keyy[48];
    uint8_t ecdh_shared_keyx[48];

    uint32_t ecdh_keyx[12];
    uint32_t ecdh_keyy[12];

    int32_t i;
    uint8_t *p;

    struct bflb_ecdh_s ecdh_handle;
    uint32_t time1, time2;

    board_init();

    printf("ECDH 384 Case\r\n");

    bflb_sec_ecdh_init(&ecdh_handle, ECP_SECP384R1);
    printf("ECP_SECP384R1\r\n");
    BUFF_COPY(secp384r1);

    printf("Bob calculate encrypt key\r\n");
    time1 = (unsigned int)bflb_mtimer_get_time_us();
    bflb_sec_ecdh_get_encrypt_key(&ecdh_handle, (uint32_t *)ecdh_public_keyx1, (uint32_t *)ecdh_public_keyy1, (uint32_t *)ecdh_private_key2, ecdh_keyx, ecdh_keyy);
    time2 = (unsigned int)bflb_mtimer_get_time_us();
    printf("Get encrypt key time=%dus\r\n", (time2 - time1));

    p = (uint8_t *)ecdh_keyx;

    for (i = 0; i < 48; i++) {
        if (ecdh_shared_keyx2[i] != p[i]) {
            printf("ECDH Compare fail\r\n");
            printf("p[%d]=0x%x\r\n", i, p[i]);
        }
    }

    printf("Alice calculate encrypt key\r\n");
    time1 = (unsigned int)bflb_mtimer_get_time_us();
    bflb_sec_ecdh_get_encrypt_key(&ecdh_handle, (uint32_t *)ecdh_public_keyx2, (uint32_t *)ecdh_public_keyy2, (uint32_t *)ecdh_private_key1, ecdh_keyx, ecdh_keyy);
    time2 = (unsigned int)bflb_mtimer_get_time_us();
    printf("Get encrypt key time=%dus\r\n", (time2 - time1));

    p = (uint8_t *)ecdh_keyx;

    for (i = 0; i < 48; i++) {
        if (ecdh_shared_keyx1[i] != p[i]) {
            printf("ECDH Compare fail\r\n");
            printf("p[%d]=0x%x\r\n", i, p[i]);
        }
    }

    printf("Another case\r\n");
    printf("Get Public key\r\n");
    time1 = (unsigned int)bflb_mtimer_get_time_us();
    bflb_sec_ecdh_get_public_key(&ecdh_handle, (uint32_t *)ecdh_private_key, ecdh_keyx, ecdh_keyy);
    time2 = (unsigned int)bflb_mtimer_get_time_us();
    printf("Get public key time=%dus\r\n", (time2 - time1));

    p = (uint8_t *)ecdh_keyx;

    for (i = 0; i < 48; i++) {
        if (ecdh_public_keyx[i] != p[i]) {
            printf("ECDH Compare fail\r\n");
            printf("p[%d]=0x%x\r\n", i, p[i]);
        }
    }

    p = (uint8_t *)ecdh_keyy;

    for (i = 0; i < 48; i++) {
        if (ecdh_public_keyy[i] != p[i]) {
            printf("ECDH Compare fail\r\n");
            printf("p[%d]=0x%x\r\n", i, p[i]);
        }
    }

    printf("Get shared key\r\n");

    time1 = (unsigned int)bflb_mtimer_get_time_us();
    bflb_sec_ecdh_get_encrypt_key(&ecdh_handle, ecdh_keyx, ecdh_keyy, (uint32_t *)ecdh_private_key, ecdh_keyx, ecdh_keyy);
    time2 = (unsigned int)bflb_mtimer_get_time_us();
    printf("Get share key time=%dus\r\n", (time2 - time1));

    p = (uint8_t *)ecdh_keyx;

    for (i = 0; i < 48; i++) {
        if (ecdh_shared_keyx[i] != p[i]) {
            printf("ECDH Compare fail\r\n");
            printf("p[%d]=0x%x\r\n", i, p[i]);
        }
    }

    while (1) {
        bflb_mtimer_delay_ms(2000);
    }
}